# Keil uVision project Motor_board_ad7799_RTD.uvprojx, settings and files
target Target (6140000::V6.14::ARMCLANG)
  device: STM32G070KBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Motor_board_ad7799_RTD
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Motor_board_ad7799_RTD;.\CMSIS\inc;.\Startup;.\Code\inc;.\SSD1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Code
    ./Code/src/: main.c system_init.c delay.c dcm.c uart.c OWEN_485.c timer.c data_convert.c ad7799.c spi.c i2c.c
  group CMSIS
    ./CMSIS/src/: system_stm32g0xx.c
  group Startup
    ./Startup/: startup_stm32g070xx.s
  group SSD1306
    ./SSD1306/: ssd1306.c ssd1306_fonts.c
